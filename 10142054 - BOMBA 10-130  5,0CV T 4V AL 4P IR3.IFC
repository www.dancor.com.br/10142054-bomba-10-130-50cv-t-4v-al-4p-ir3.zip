Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 10142054 - BOMBA 10-130 5,0CV T 4V AL 4P IR3.IFC
Time: 2024-02-16T11:48:36
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: CARCAÇA 17-120 - 60380007_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: C_PT_M12352997-3D.IGS<1>[1] (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: C_PT_M12352997-3D.IGS<1>[2] (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: C_PT_M12352997-3D.IGS<1>[3] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: C_PT_M12352997-3D.IGS<1>[4] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: C_PT_M12352997-3D.IGS<1>[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: C_PT_M12352997-3D.IGS<1>[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Interm. 17-120 FC-149 - 6cv_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: PARAFUSO SEXTAVADO UNC 1-2'' x 1'' SALT SPRAY 96h - 60700041_Default (8)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: PARAFUSO SEXTAVADO UNC 3-8'' x 1'' SALT SPRAY 96h - 60700183 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PLUG DE ESCORVA LATÃO 3-8'' - 60550166_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Latão

# IfcBuildingElementProxy: REFERENCE_SOLID.IGS
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: W22_JM_JP_DE_ENDSHIELD_100_FC-NEMA.IGS
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: W22_JM_JP_DE_SHAFT_100JM.IGS
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: W22_NDE_ENDSHIELD_L100.IGS
In: Default Storey
PredefinedType: ELEMENT; Material: 0
